<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\BMP_280 Nucleo_L031K6.ewp</path>
  </project>
  <batchBuild />
</workspace>
